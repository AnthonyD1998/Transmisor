options:
  parameters:
    author: Anthony Rodríguez
    generate_options: qt_gui
    id: defaul
    output_language: python
    title: Transmision en banda base
  states: {}

blocks:
- name: low_frec
  id: variable_qtgui_range
  parameters:
    label: Lower cut-of frecuency
    orient: Qt.Horizontal
    start: '20'
    step: '1000'
    stop: '30000'
    value: '20'
  states: {}
- name: noice
  id: variable_qtgui_range
  parameters:
    label: Amound of noice
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '0.4'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: up_frec
  id: variable_qtgui_range
  parameters:
    label: Upper cut off frecuency
    orient: Qt.Horizontal
    start: '20'
    step: '1000'
    stop: '30000'
    value: '20000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: up_frec
    low_cutoff_freq: low_frec
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Anthony\Desktop\Transmisor\Triple H.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
